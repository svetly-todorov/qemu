## hw/cxl/Kconfig
```kconfig
source vendor/Kconfig

config CXL
    bool
    default y if PCI_EXPRESS

config CXL_VENDOR
    bool
    default y
```
